FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://md_faulty_disable.cfg"